Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: Project Number
Time: 2022-12-21T15:17:50
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20190327_2315(x64) - Exporter 20.0.0.377 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Wed Dec 21 15:17:50 2022 * Host: DSBIRNE-RO-LE * Database: C:\Users\DSbirne\AppData\Local\Temp\e3ff18ec-1589-47a6-92e9-616b39fa2ce7\ac871142-a784-424e-b49f-3b50bda4a9ec\ifc * Database version: 5507 * Database creation date: Wed Dec 21 15:17:49 2022 * Schema: IFC4 * Model: DataRepository.ifc * Model creation date: Wed Dec 21 15:17:49 2022 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Wed Dec 21 15:17:49 2022 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 23, 13, 199999; RefLongitude: -71, -14, -31, -199999; RefElevation: 0 mm
Dimensions - S4R_Use_nominal_diameter: yes
Other - Category: Project Information; Client Name: Client Name; Project Address: Enter address here; Project Issue Date: Project Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - Reference: Project Information; NumberOfStoreys: 1
Dimensions - S4R_Use_nominal_diameter: yes
Other - Category: Project Information; Client Name: Client Name; Project Address: Enter address here; Project Issue Date: Project Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuildingStorey: Level:Floor Level, F00
LongName: F00; Elevation: 0 mm
Other(Type) - Category: Levels; Family Name: Level
Identity Data(Type) - Type Name: Floor Level
Graphics(Type) - Color: 0; Line Pattern: Solid; Line Weight: 1; Symbol: GE_tag_level_floor_MEPcontent: standard; Symbol at End 1 Default: yes; Symbol at End 2 Default: yes
Constraints(Type) - Elevation Base: Project Base Point
Pset_BuildingStoreyCommon - Reference: Floor Level
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: F00; Structural: no
Other - Category: Levels; Family: Level: Floor Level; Family and Type: Level: Floor Level; Type: Level: Floor Level; Type Id: Level: Floor Level

# IfcDistributionPort, Port_2298708
Description: Flow; FlowDirection: SOURCEANDSINK

# IfcOutlet: Reflex SI_2CKA001725A0936_hor_2, E_Frame Horizontal_Socket_F_MEPcontent_SWiRAC_ABB BUSCH-JAEGER_Reflex SI_2CKA001725A0936_2CKA002014A1473_NL-EN:Reflex SI_2CKA001725A0936_hor_2:2298708
In: F00
Type - PredefinedType: POWEROUTLET; Material: Color RAL 9010
Type - Constraints - Default Elevation: 0 mm
Type - Dimensions - Depth: 11 mm; Frame Thickness: 16 mm; Gang Height: 55 mm; Gang Width: 55 mm; Height: 81 mm; Rotation U-Axis Correction: 0 deg; Rotation V-Axis Correction: 0 deg; Rotation W-Axis Correction: 0 deg; Rounding Gang: 8 mm; Rounding Radius: 11 mm; Width: 152 mm
Type - Electrical - App ID: EL_MODELPARTSYSTEM; Frame Type: Alpine white; Material: Color RAL 9010; Number of Gangs: 2
Type - Identity Data - Article Code: Default; Article Description: Cover frame, alpine white, Frame Reflex SI; Article Type: 2-gang frame; Base Family Version: 20221128; Category: EL_SYMBOL_ARTICLE; Content Supplier URL: www.MEPcontent.com; Custom: no; Description: Cover frame, alpine white, Frame Reflex SI; EMCS Version: 4.0; ETIM Article Class: EC000007; Family Version: 22.13; GLN: 8712507900012; GTIN: 4011395099209; Manufacturer: ABB BUSCH-JAEGER; Manufacturer Art. No.: 2CKA001725A0936; Manufacturer Type: 2512-214; Manufacturer URL: https://www.abbconnect.nl/artlink.aspx?id=4011395099209&LanguageCode=NL&Country=NL; MEPcontent Class: ELECTRICAL_FIXTURES; Model: 2-gang frame; OmniClass Number: 23.80.50.11; OmniClass Title: Switches and Receptacles; Product Line: Reflex SI; Revit Version: 2020; Type Name: Reflex SI_2CKA001725A0936_hor_2; URL: https://mep.trimble.com; Watermarked By: https://mep.trimble.com
Type - Model Properties - 3D Representation: 3DGeometry
Type - Other - Category: Data Devices; Family Name: E_Frame Horizontal_Socket_F_MEPcontent_SWiRAC_ABB BUSCH-JAEGER_Reflex SI_2CKA001725A0936_2CKA002014A1473_NL-EN
Type - Pset_EnvironmentalImpactIndicators - Reference: Reflex SI_2CKA001725A0936_hor_2
Type - Pset_ManufacturerTypeInformation - Manufacturer: ABB BUSCH-JAEGER
Type - Pset_OutletTypeCommon - Reference: Reflex SI_2CKA001725A0936_hor_2
Pset_EnvironmentalImpactIndicators - sets with these values: 2
Constraints - Annotation Offset: 0 mm; Annotation Offset RL: 0 mm; Elevation from Level: 0 mm
Dimensions - Area: 0.0227746 m2; Rotation U-Axis: 0 deg; Rotation V-Axis: 0 deg; Rotation W-Axis: 0 deg; Volume: 0.00006065 m3
Electrical - Circuiting - Electrical Data: Power - Balanced 230 V/1-200 VA
Electrical - Loads - Load Classification: Power; Power: 200 W
Identity Data - Copyright: © Trimble Europe BV; Mark: 2; VERSION: 221300
Other - Family: E_Frame Horizontal_Socket_F_MEPcontent_SWiRAC_ABB BUSCH-JAEGER_Reflex SI_2CKA001725A0936_2CKA002014A1473_NL-EN: Reflex SI_2CKA001725A0936_hor_2; Family and Type: E_Frame Horizontal_Socket_F_MEPcontent_SWiRAC_ABB BUSCH-JAEGER_Reflex SI_2CKA001725A0936_2CKA002014A1473_NL-EN: Reflex SI_2CKA001725A0936_hor_2; Gang 3: 71 mm; Gang Reference Line: 126 mm; Interior Width: 27.5 mm; Number of Representation Line: 2; Type: E_Frame Horizontal_Socket_F_MEPcontent_SWiRAC_ABB BUSCH-JAEGER_Reflex SI_2CKA001725A0936_2CKA002014A1473_NL-EN: Reflex SI_2CKA001725A0936_hor_2; Type Id: E_Frame Horizontal_Socket_F_MEPcontent_SWiRAC_ABB BUSCH-JAEGER_Reflex SI_2CKA001725A0936_2CKA002014A1473_NL-EN: Reflex SI_2CKA001725A0936_hor_2
Phasing - Phase Created: 4. Plan over 10 years

# IfcOutlet: Reflex SI_with Earth 2F_20-2 EUC-214-503, E_Socket_F_MEPcontent_SWiRAC_ABB BUSCH-JAEGER_Reflex SI_2CKA002014A1473_NL-EN:Reflex SI_with Earth 2F_20-2 EUC-214-503:2298712
In: F00
Type - PredefinedType: POWEROUTLET; Material: Color RAL 9010, Color RGB 120-120-120
Type - Constraints - Default Elevation: 2800 mm
Type - Dimensions - Rotation U-Axis Correction: 0 deg; Rotation V-Axis Correction: 0 deg; Rotation W-Axis Correction: 0 deg; Depth: 40 mm; Height: 71 mm; Rounding Radius: 8 mm; Width: 143 mm
Type - Electrical - Material: Color RAL 9010; App ID: EL_MODELPARTSYSTEM; Insert Type: Alpine white
Type - Identity Data - Custom: no; Article Code: Default; Article Description: Wall socket (Reflex) SI wcd ra double insect screen cpl R-alpin; Article Type: Reflex SI_with Earth 2F_20-2 EUC-214-503; Base Family Version: 20221128; Category: EL_POWERCONSUMER; Content Supplier URL: www.MEPcontent.com; Description: Wall socket (Reflex) SI wcd ra double insect screen cpl R-alpin; EMCS Version: 4.0; ETIM Article Class: EC000125; Family Version: 11.23; GLN: 8712507900012; GTIN: 4011395103333; Manufacturer: ABB BUSCH-JAEGER; Manufacturer Art. No.: 2CKA002014A1473; Manufacturer Type: 20-2 EUC-214-503; Manufacturer URL: https://www.abbconnect.nl/artlink.aspx?id=4011395103333&LanguageCode=NL&Country=NL; MEPcontent Class: ELECTRICAL_FIXTURES; Model: Reflex SI_with Earth 2F_20-2 EUC-214-503; OmniClass Number: 23.80.50.00; OmniClass Title: Terminals for Power Supply; Product Line: Reflex SI; Revit Version: 2020; Type Name: Reflex SI_with Earth 2F_20-2 EUC-214-503; URL: https://mep.trimble.com; Watermarked By: https://mep.trimble.com
Type - Model Properties - 3D Representation: 3DGeometry
Type - Other - Category: Electrical Fixtures; Family Name: E_Socket_F_MEPcontent_SWiRAC_ABB BUSCH-JAEGER_Reflex SI_2CKA002014A1473_NL-EN
Type - Visibility - Number Of Representation: 1
Type - Pset_EnvironmentalImpactIndicators - Reference: Reflex SI_with Earth 2F_20-2 EUC-214-503
Type - Pset_ManufacturerTypeInformation - Manufacturer: ABB BUSCH-JAEGER
Type - Pset_OutletTypeCommon - Reference: Reflex SI_with Earth 2F_20-2 EUC-214-503
Pset_EnvironmentalImpactIndicators - sets with these values: 2
Constraints - Annotation Offset: 0 mm; Annotation Offset RL: 0 mm; Annotation: 19; Moves With Nearby Elements: no; Position Condition: 0
Dimensions - Rotation U-Axis: 0 deg; Rotation V-Axis: 0 deg; Rotation W-Axis: 0 deg; Area: 0.0273239 m2; Volume: 0.00022767 m3
Electrical - Loads - Load Classification: Power; Power: 0 W
Identity Data - Copyright: © Trimble Europe BV; Mark: 6; VERSION: 221200
Other - Annotation SocketOneFoldWithEarth: yes; Family: E_Socket_F_MEPcontent_SWiRAC_ABB BUSCH-JAEGER_Reflex SI_2CKA002014A1473_NL-EN: Reflex SI_with Earth 2F_20-2 EUC-214-503; Family and Type: E_Socket_F_MEPcontent_SWiRAC_ABB BUSCH-JAEGER_Reflex SI_2CKA002014A1473_NL-EN: Reflex SI_with Earth 2F_20-2 EUC-214-503; Type: E_Socket_F_MEPcontent_SWiRAC_ABB BUSCH-JAEGER_Reflex SI_2CKA002014A1473_NL-EN: Reflex SI_with Earth 2F_20-2 EUC-214-503; Type Id: E_Socket_F_MEPcontent_SWiRAC_ABB BUSCH-JAEGER_Reflex SI_2CKA002014A1473_NL-EN: Reflex SI_with Earth 2F_20-2 EUC-214-503
Phasing - Phase Created: 4. Plan over 10 years
